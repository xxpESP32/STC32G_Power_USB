# Keil uVision project voltage_current_check.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: voltage_current_check +hex
  group Source Group 1
    ./voltage_current_check/: main.c
  group ADC
    ./ADC/: ADC.c
  group I2C
    ./I2C/: AHT10.c I2C.c
  group LCD
    ./LCD/: lcd.c lcd_init.c
  group USART1
    ./UART1/: uart1.c usart2.c
  group System
    ./System/: SYSTEM.c
  group Menu
    ./Menu/: menu.c menu_Ui.c
  group Key
    ./KEY/: KEY.c
  group Timer
    ./Timer/: Timer.c
  group SPI_Handler
    ./SPI_Handler/: Spi_Handler.c
  group CH224K
    ./CH224K/: CH224K.c
  group Pwm
    ./Pwm/: Pwm.c
